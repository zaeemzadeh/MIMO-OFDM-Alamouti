<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MIMO_CHANNEL</value></param>
<param><key>title</key><value>MIMO Channel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MIMO</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>seed</value></param>
<param><key>label</key><value>Seed</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>label</key><value>Epsilon</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise</value></param>
<param><key>label</key><value>Noise Voltage</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>gr_delay_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>out1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>gr_delay_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>noise/2</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>epsilon</key><value>epsilon</value></param>
<param><key>taps</key><value>0.5+0.7j</value></param>
<param><key>seed</key><value>seed</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_2</value></param>
<param><key>noise_voltage</key><value>noise/2</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>epsilon</key><value>epsilon</value></param>
<param><key>taps</key><value>0.4 + 0.3j</value></param>
<param><key>seed</key><value>seed + 1</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_1</value></param>
<param><key>noise_voltage</key><value>noise/2</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>epsilon</key><value>epsilon</value></param>
<param><key>taps</key><value>0.8 + 0.1j</value></param>
<param><key>seed</key><value>seed + 2</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_3</value></param>
<param><key>noise_voltage</key><value>noise/2</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>epsilon</key><value>epsilon</value></param>
<param><key>taps</key><value>0.3 + 0.7j</value></param>
<param><key>seed</key><value>seed + 3</value></param>
</block>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>gr_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>gr_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channels_channel_model_3</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_delay_0_0</source_block_id><sink_block_id>channels_channel_model_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0_1</source_block_id><sink_block_id>channels_channel_model_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0_1</source_block_id><sink_block_id>channels_channel_model_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
